## src/examples/my_controller/Kconfig
```kconfig
menuconfig EXAMPLES_MY_CONTROLLER
    bool "my_controller"
    default n
    ---help---
        Enable support for my_controller
```
